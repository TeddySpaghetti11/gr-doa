options:
  parameters:
    author: gr-doa LibreSDR research port
    comment: Four-channel LibreSDR UCA MUSIC with a fixed calibration beacon and a separate movable target.
    description: Continuously tracked +140 kHz calibration pilot and independently filtered +150 kHz target for live direction finding.
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    hier_block_src_path: ''
    id: run_MUSIC_uca_live_cal
    output_language: python
    title: LibreSDR UCA MUSIC - Live OTA Calibration
  states: {}

blocks:
- name: array_radius
  id: variable
  parameters:
    comment: Physical UCA radius in metres from 162.63 mm adjacent chord spacing
    value: 0.16263 / (2**0.5)
  states: {}
- name: calibration_file
  id: variable
  parameters:
    comment: Diagnostic copy of frozen phase coefficients
    value: '"/tmp/gr-doa-uca-phase-offsets.cfg"'
  states: {}
- name: calibration_samples
  id: variable
  parameters:
    comment: Filtered pilot samples used for complex averaging/coherence
    value: 2**12
  states: {}
- name: calibration_skip
  id: variable
  parameters:
    comment: Filtered samples skipped before calibration
    value: 2**11
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: LibreSDR and B210 RF centre frequency
    value: int(700e6)
  states: {}
- name: cfo_agreement_tolerance_hz
  id: variable
  parameters:
    comment: Maximum accepted disagreement between ch2/ch0 and ch3/ch0
    value: '10.0'
  states: {}
- name: cfo_estimation_samples
  id: variable
  parameters:
    comment: Raw OTA pilot samples in each Bravo-vs-Alpha CFO window
    value: 2**16
  states: {}
- name: cfo_max_abs_hz
  id: variable
  parameters:
    comment: Reject implausibly large Bravo-minus-Alpha CFO estimates
    value: '20000.0'
  states: {}
- name: cfo_max_refinement_rounds
  id: variable
  parameters:
    comment: Maximum closed-loop residual correction attempts before rejecting and retrying
    value: '3'
  states: {}
- name: cfo_min_coherence
  id: variable
  parameters:
    comment: Minimum narrow-pilot coherence for coarse and residual CFO estimates
    value: '0.90'
  states: {}
- name: cfo_residual_tolerance_hz
  id: variable
  parameters:
    comment: Maximum averaged post-correction residual CFO allowed before cfo_locked
    value: '1.0'
  states: {}
- name: cfo_retry_delay_samples
  id: variable
  parameters:
    comment: Raw samples to pass before retrying a rejected CFO window
    value: 2**16
  states: {}
- name: cfo_settling_samples
  id: variable
  parameters:
    comment: Five-second IIO/RF/PLL settling before cross-SDR CFO estimation
    value: int(5 * samp_rate)
  states: {}
- name: cfo_validation_settling_samples
  id: variable
  parameters:
    comment: Corrected raw samples to settle before each residual validation window
    value: 2**12
  states: {}
- name: element0_bearing
  id: variable
  parameters:
    comment: 192.168.4.1 RX1 top-right element
    value: '315.0'
  states: {}
- name: element_bearing_step
  id: variable
  parameters:
    comment: Physical stream order proceeds counter-clockwise around the UCA
    value: '90.0'
  states: {}
- name: norm_radius
  id: variable
  parameters:
    comment: Frequency-derived UCA radius in wavelengths
    value: array_radius * pilot_rf / 299792458.0
  states: {}
- name: num_elements
  id: variable
  parameters:
    comment: Two RX channels per LibreSDR
    value: '4'
  states: {}
- name: num_targets
  id: variable
  parameters:
    comment: Known number of narrowband sources
    value: '1'
  states: {}
- name: overlap_size
  id: variable
  parameters:
    comment: Covariance snapshot overlap
    value: '0'
  states: {}
- name: pilot_bearing
  id: variable
  parameters:
    comment: Source bearing from array centre towards the B210 pilot
    value: '180'
  states: {}
- name: pilot_decim
  id: variable
  parameters:
    comment: Identical decimation in all four pilot filters
    value: '2'
  states: {}
- name: pilot_offset
  id: variable
  parameters:
    comment: B210 complex tone offset from centre frequency
    value: 140e3
  states: {}
- name: pilot_passband
  id: variable
  parameters:
    comment: Low-pass cutoff after translating the pilot to DC
    value: 2e3
  states: {}
- name: pilot_rf
  id: variable
  parameters:
    comment: Actual RF of the fixed calibration pilot
    value: center_freq + pilot_offset
  states: {}
- name: pilot_transition
  id: variable
  parameters:
    comment: Pilot LPF transition width
    value: 2e3
  states: {}
- name: proc_rate
  id: variable
  parameters:
    comment: Sample rate after pilot filtering/decimation
    value: samp_rate / pilot_decim
  states: {}
- name: pspectrum_len
  id: variable
  parameters:
    comment: 360 bins gives 1 degree scan spacing and halves MUSIC scan load
    value: '360'
  states: {}
- name: rf_bandwidth
  id: variable
  parameters:
    comment: Requested AD9361 RF bandwidth
    value: int(2.8e6)
  states: {}
- name: rx_gain
  id: variable
  parameters:
    comment: Same manual gain on all four channels
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: LibreSDR complex sample rate
    value: int(525e3)
  states: {}
- name: snapshot_size
  id: variable
  parameters:
    comment: Samples per MUSIC covariance estimate
    value: 2**11
  states: {}
- name: target_norm_radius
  id: variable
  parameters:
    comment: UCA radius in wavelengths at the target RF, used by MUSIC
    value: array_radius * target_rf / 299792458.0
  states: {}
- name: target_calibration_bearing
  id: variable
  parameters:
    comment: Hold the movable target at this known bearing until UCA calibration completes
    value: '345.0'
  states: {}
- name: target_offset
  id: variable
  parameters:
    comment: Movable B210 TX/RX1 target offset from centre frequency
    value: 150e3
  states: {}
- name: target_rf
  id: variable
  parameters:
    comment: Actual RF of the direction-finding target
    value: center_freq + target_offset
  states: {}
- name: alpha_internal_phase_display
  id: qtgui_time_sink_x
  parameters:
    comment: Same-device Alpha RX phase before filtering.
    entags: 'False'
    grid: 'True'
    gui_hint: 4,0,1,1
    label1: arg(A RX1 * conj(A RX2))
    name: '"Alpha internal pre-filter phase: RX1 vs RX2"'
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: Phase
    ymax: '3.2'
    ymin: '-3.2'
    yunit: radians
  states: {state: disabled}
- name: alpha_internal_phase_estimator
  id: doa_phase_offset_est
  parameters:
    comment: Alpha-only direct IIO phase diagnostic; input 0 is RX1 and input 1 is RX2.
    n_skip_ahead: calibration_skip * pilot_decim
    num_inputs: '2'
  states: {state: disabled}
- name: bearing_display
  id: qtgui_number_sink
  parameters:
    comment: Strongest MUSIC local maximum; inspect the spectrum before trusting a tied/flat result.
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 0,0,1,1
    label1: Estimated bearing
    max: '360'
    min: '0'
    name: '"UCA MUSIC bearing"'
    type: float
    unit1: degrees
  states: {}
- name: bearing_streams
  id: blocks_vector_to_streams
  parameters:
    num_streams: num_targets
    type: float
  states: {}
- name: bearing_validity
  id: doa_bearing_validity_gate
  parameters:
    comment: Hold the most recent valid bearing through invalid intervals.
    validity_tag_key: doa_valid
    vector_length: num_targets
  states: {}
- name: bravo_internal_phase_display
  id: qtgui_time_sink_x
  parameters:
    comment: Same-device Bravo RX phase before filtering. Input 0 is B RX1 and input 1 is B RX2, independent of the UCA permutation.
    entags: 'False'
    grid: 'True'
    gui_hint: 4,1,1,1
    label1: arg(B RX1 * conj(B RX2))
    name: '"Bravo internal pre-filter phase: RX1 vs RX2"'
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: Phase
    ymax: '3.2'
    ymin: '-3.2'
    yunit: radians
  states: {state: disabled}
- name: bravo_internal_phase_estimator
  id: doa_phase_offset_est
  parameters:
    comment: Bravo-only direct IIO phase diagnostic; input 0 is RX1 and input 1 is RX2.
    n_skip_ahead: calibration_skip * pilot_decim
    num_inputs: '2'
  states: {state: disabled}
- name: cfo_correction
  id: doa_cross_sdr_cfo_corrector
  parameters:
    agreement_tolerance_hz: cfo_agreement_tolerance_hz
    comment: 'Fixed order: ch0 Alpha RX1, ch1 Alpha RX2, ch2 Bravo RX2, ch3 Bravo RX1. Alpha is untouched; one common rotator corrects both Bravo channels.'
    estimation_samples: cfo_estimation_samples
    max_abs_cfo_hz: cfo_max_abs_hz
    max_refinement_rounds: cfo_max_refinement_rounds
    min_coherence: cfo_min_coherence
    pilot_bandwidth_hz: pilot_passband
    pilot_offset_hz: pilot_offset
    post_lock_tracking_window_samples: '16384'
    residual_tolerance_hz: cfo_residual_tolerance_hz
    retry_delay_samples: cfo_retry_delay_samples
    samp_rate: samp_rate
    settling_samples: cfo_settling_samples
    tracking_agreement_tolerance_hz: '1.0'
    tracking_bad_window_grace: '3'
    tracking_frequency_gain: '0.25'
    tracking_gain: '1.0'
    tracking_lock_tolerance_hz: '0.15'
    tracking_lock_windows: '2'
    tracking_max_residual_hz: '150.0'
    tracking_min_coherence: '0.9'
    tracking_warmup_samples: '4096'
    tracking_window_samples: '16384'
    transition_confirm_windows: '2'
    transition_frequency_gain: '1.0'
    transition_threshold_hz: '5.0'
    validation_settling_samples: cfo_validation_settling_samples
  states: {state: disabled}
- name: direct_phase_correction
  id: doa_cross_sdr_pilot_phase_corrector
  parameters:
    acquisition_samples: '8192'
    comment: Direct pilot-referenced correction at the decimated rate. Captures the initial Alpha-to-Bravo phase as part of the array calibration, then removes only subsequent common Bravo phase motion sample by sample. This replaces the frequency-state estimator/recovery loop in the live bearing path.
    max_differential_phase_rad: '0.35'
    max_alignment_lag: '256'
    min_coherence: '0.95'
    min_valid_fraction: '0.90'
    phase_smoothing_samples: '64'
    settling_samples: int(5 * proc_rate)
  states: {}
- name: pilot_aligned_vectorizer
  id: blocks_streams_to_vector
  parameters:
    num_streams: '4'
    type: complex
  states: {}
- name: pilot_output_decimator
  id: blocks_keep_one_in_n
  parameters:
    n: '4'
    type: complex
    vlen: '4'
  states: {}
- name: pilot_aligned_streams
  id: blocks_vector_to_streams
  parameters:
    num_streams: '4'
    type: complex
  states: {state: disabled}
- name: pilot_aligned_discard
  id: blocks_null_sink
  parameters:
    type: complex
    vlen: '4'
  states: {}
- name: target_aligned_vectorizer
  id: blocks_streams_to_vector
  parameters:
    num_streams: '4'
    type: complex
  states: {}
- name: target_output_decimator
  id: blocks_keep_one_in_n
  parameters:
    n: '4'
    type: complex
    vlen: '4'
  states: {}
- name: target_aligned_streams
  id: blocks_vector_to_streams
  parameters:
    num_streams: '4'
    type: complex
  states: {}
- name: corrected_channels
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 0,1,1,1
    label1: Element 0
    label2: Element 1
    label3: Element 2
    label4: Element 3
    name: '"Calibrated movable-target channels"'
    nconnections: '4'
    size: '1024'
    srate: proc_rate
    type: complex
  states: {state: disabled}
- name: corrected_phase_display
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: 2,1,1,1
    label1: Corrected ch1/ch0
    label2: Corrected ch2/ch0
    label3: Corrected ch3/ch0
    name: '"Corrected target relative phase (instantaneous)"'
    nconnections: '3'
    size: '1024'
    srate: proc_rate
    type: float
    ylabel: Phase
    ymax: '3.2'
    ymin: '-3.2'
    yunit: radians
  states: {state: disabled}
- name: corrected_phase_estimator
  id: doa_phase_offset_est
  parameters:
    comment: Instantaneous x0*conj(xi) phase of the separately filtered target after pilot-derived calibration.
    n_skip_ahead: calibration_skip + calibration_samples
    num_inputs: num_elements
  states: {state: disabled}
- name: covariance
  id: doa_autocorrelate
  parameters:
    avg_method: Forward
    comment: Target-only forward covariance; the calibration pilot does not enter MUSIC.
    inputs: num_elements
    invalid_tag_key: calibration_invalid
    overlap_size: overlap_size
    output_valid_tag_key: doa_valid
    snapshot_size: snapshot_size
    valid_tag_key: calibration_valid
  states: {}
- name: libresdr_a
  id: iio_fmcomms2_source
  parameters:
    bandwidth: rf_bandwidth
    bbdc: 'True'
    buffer_size: '1048576'
    comment: Element 0 = RX1 top-right; element 1 = RX2 top-left.
    filter_source: '''Auto'''
    frequency: center_freq
    gain1: '''manual'''
    gain2: '''manual'''
    manual_gain1: rx_gain
    manual_gain2: rx_gain
    quadrature: 'False'
    rf_port_select: '''A_BALANCED'''
    rfdc: 'True'
    rx1_en: 'True'
    rx2_en: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.4.1
  states: {}
- name: libresdr_b
  id: iio_fmcomms2_source
  parameters:
    bandwidth: rf_bandwidth
    bbdc: 'True'
    buffer_size: '1048576'
    comment: 'Outputs are permuted below: RX2 bottom-left = element 2; RX1 bottom-right = element 3.'
    filter_source: '''Auto'''
    frequency: center_freq
    gain1: '''manual'''
    gain2: '''manual'''
    manual_gain1: rx_gain
    manual_gain2: rx_gain
    quadrature: 'False'
    rf_port_select: '''A_BALANCED'''
    rfdc: 'True'
    rx1_en: 'True'
    rx2_en: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.5.1
  states: {}
- name: music_uca
  id: doa_MUSIC_uca
  parameters:
    comment: Full-circle source-bearing UCA steering model.
    element0_angle: element0_bearing
    element_angle_step: element_bearing_step
    inputs: num_elements
    norm_radius: target_norm_radius
    num_targets: num_targets
    pspectrum_len: pspectrum_len
  states: {}
- name: ota_calibration
  id: doa_uca_pilot_calibration
  parameters:
    calibration_samples: calibration_samples
    comment: Same-frequency startup calibration. Hold the movable target at target_calibration_bearing until complete; the fixed beacon is used for alignment/tracking only.
    config_filename: calibration_file
    element0_angle: element0_bearing
    element_angle_step: element_bearing_step
    min_coherence: '0.97'
    minoutbuf: '65536'
    norm_radius: target_norm_radius
    num_inputs: num_elements
    pilot_angle: target_calibration_bearing
    retry_on_failure: 'True'
    separate_data_inputs: 'True'
    skip_samples: calibration_skip
    start_tag_key: '''cfo_locked'''
  states: {}
- name: peak_finder
  id: doa_find_local_max
  parameters:
    num_max_vals: num_targets
    vector_len: pspectrum_len
    x_max: '360.0'
    x_min: '0.0'
  states: {}
- name: peak_magnitude_discard
  id: blocks_null_sink
  parameters:
    type: float
    vlen: num_targets
  states: {}
- name: pilot_filter_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: pilot_offset
    comment: Element 0 pilot selector
    decim: pilot_decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, pilot_passband, pilot_transition)
    type: ccc
  states: {}
- name: pilot_filter_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: pilot_offset
    comment: Element 1 pilot selector
    decim: pilot_decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, pilot_passband, pilot_transition)
    type: ccc
  states: {}
- name: pilot_filter_2
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: pilot_offset
    comment: Element 2 pilot selector (LibreSDR B RX2)
    decim: pilot_decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, pilot_passband, pilot_transition)
    type: ccc
  states: {}
- name: pilot_filter_3
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: pilot_offset
    comment: Element 3 pilot selector (LibreSDR B RX1)
    decim: pilot_decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, pilot_passband, pilot_transition)
    type: ccc
  states: {}
- name: post_cfo_fft_display
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: proc_rate
    comment: CFO-corrected streams after the existing translating/decimating pilot filters. All four pilot peaks should coincide after CFO lock.
    fc: '0'
    fftsize: '8192'
    grid: 'True'
    label1: A RX1 / element 0
    label2: A RX2 / element 1
    label3: B RX2 / element 2
    label4: B RX1 / element 3
    name: '"POST-CFO filtered pilot spectra (8192-bin FFT)"'
    nconnections: '4'
    type: complex
    update_time: '0.20'
  states: {state: disabled}
- name: postfilter_phase_display
  id: qtgui_time_sink_x
  parameters:
    comment: This diagnostic is after the common CFO correction and four identical translating/decimating FIR filters, but before constant phase calibration.
    entags: 'False'
    grid: 'True'
    gui_hint: 2,0,1,1
    label1: POST-CFO A RX2 vs A RX1
    label2: POST-CFO B RX2 vs A RX1
    label3: POST-CFO B RX1 vs A RX1
    name: '"POST-CFO relative phase (before phase calibration)"'
    nconnections: '3'
    size: '1024'
    srate: proc_rate
    type: float
    ylabel: Phase
    ymax: '3.2'
    ymin: '-3.2'
    yunit: radians
  states: {state: disabled}
- name: postfilter_phase_estimator
  id: doa_phase_offset_est
  parameters:
    comment: POST-CFO Ettus arg(x0*conj(xi)) diagnostic before constant phase calibration.
    n_skip_ahead: calibration_skip
    num_inputs: num_elements
  states: {state: disabled}
- name: pps_sync_before_start
  id: snippet
  parameters:
    code: doa.arm_libresdr_pps_sync(('ip:192.168.4.1', 'ip:192.168.5.1'))
    comment: Arm and verify both FPGA sample epochs before GNU Radio starts filling independent source buffers.
    section: main_after_init
  states: {}
- name: prefilter_phase_display
  id: qtgui_time_sink_x
  parameters:
    comment: Connected directly to IIO outputs before every FIR, calibration, or correction block. Physical order is A RX1, A RX2, B RX2, B RX1.
    entags: 'False'
    grid: 'True'
    gui_hint: 3,0,1,2
    label1: TRUE PRE-FILTER A RX2 vs A RX1
    label2: TRUE PRE-FILTER B RX2 vs A RX1
    label3: TRUE PRE-FILTER B RX1 vs A RX1
    name: '"TRUE PRE-FILTER relative phase (direct IIO)"'
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: Phase
    ymax: '3.2'
    ymin: '-3.2'
    yunit: radians
  states: {state: disabled}
- name: prefilter_phase_estimator
  id: doa_phase_offset_est
  parameters:
    comment: TRUE pre-filter Ettus arg(x0*conj(xi)) diagnostic in physical order.
    n_skip_ahead: calibration_skip * pilot_decim
    num_inputs: num_elements
  states: {state: disabled}
- name: qtgui_compass_0
  id: qtgui_compass
  parameters:
    fullNeedle: '1'
    min_size: '250'
  states: {}
- name: raw_fft_display
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: TRUE pre-filter spectra in physical UCA order. Kept disabled by default because full-rate GUI diagnostics can cause IIO overruns; enable only for a short inspection after calibration is proven stable.
    fc: '0'
    fftsize: '8192'
    label1: A RX1 / element 0
    label2: A RX2 / element 1
    label3: B RX2 / element 2
    label4: B RX1 / element 3
    name: '"TRUE pre-filter raw spectra (8192-bin FFT)"'
    nconnections: '4'
    type: complex
    update_time: '0.50'
  states: {state: disabled}
- name: spectrum_display
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    gui_hint: 1,0,1,2
    label1: MUSIC pseudo-spectrum
    name: '"Full-circle UCA MUSIC"'
    vlen: pspectrum_len
    width1: '2'
    x_axis_label: '"Bearing (degrees)"'
    x_start: '0'
    x_step: 360.0/pspectrum_len
    x_units: '"degrees"'
    y_axis_label: '"Normalized pseudo-spectrum (dB)"'
    y_units: '"dB"'
    ymax: '0'
    ymin: '-7'
  states: {state: disabled}
- name: target_filter_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: target_offset
    comment: Element 0 movable-target selector
    decim: pilot_decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, pilot_passband, pilot_transition)
    type: ccc
  states: {}
- name: target_filter_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: target_offset
    comment: Element 1 movable-target selector
    decim: pilot_decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, pilot_passband, pilot_transition)
    type: ccc
  states: {}
- name: target_filter_2
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: target_offset
    comment: Element 2 movable-target selector (LibreSDR B RX2)
    decim: pilot_decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, pilot_passband, pilot_transition)
    type: ccc
  states: {}
- name: target_filter_3
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: target_offset
    comment: Element 3 movable-target selector (LibreSDR B RX1)
    decim: pilot_decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, pilot_passband, pilot_transition)
    type: ccc
  states: {}

connections:
- [alpha_internal_phase_estimator, '0', alpha_internal_phase_display, '0']
- [bearing_streams, '0', bearing_display, '0']
- [bearing_streams, '0', qtgui_compass_0, '0']
- [bravo_internal_phase_estimator, '0', bravo_internal_phase_display, '0']
- [corrected_phase_estimator, '0', corrected_phase_display, '0']
- [corrected_phase_estimator, '1', corrected_phase_display, '1']
- [corrected_phase_estimator, '2', corrected_phase_display, '2']
- [covariance, '0', music_uca, '0']
- [libresdr_a, '0', alpha_internal_phase_estimator, '0']
- [libresdr_a, '0', pilot_filter_0, '0']
- [libresdr_a, '0', target_filter_0, '0']
- [libresdr_a, '0', prefilter_phase_estimator, '0']
- [libresdr_a, '0', raw_fft_display, '0']
- [libresdr_a, '1', alpha_internal_phase_estimator, '1']
- [libresdr_a, '1', pilot_filter_1, '0']
- [libresdr_a, '1', target_filter_1, '0']
- [libresdr_a, '1', prefilter_phase_estimator, '1']
- [libresdr_a, '1', raw_fft_display, '1']
- [libresdr_b, '0', bravo_internal_phase_estimator, '0']
- [libresdr_b, '0', pilot_filter_3, '0']
- [libresdr_b, '0', target_filter_3, '0']
- [libresdr_b, '0', prefilter_phase_estimator, '3']
- [libresdr_b, '0', raw_fft_display, '3']
- [libresdr_b, '1', bravo_internal_phase_estimator, '1']
- [libresdr_b, '1', pilot_filter_2, '0']
- [libresdr_b, '1', target_filter_2, '0']
- [libresdr_b, '1', prefilter_phase_estimator, '2']
- [libresdr_b, '1', raw_fft_display, '2']
- [music_uca, '0', peak_finder, '0']
- [music_uca, '0', spectrum_display, '0']
- [ota_calibration, '0', corrected_channels, '0']
- [ota_calibration, '0', corrected_phase_estimator, '0']
- [ota_calibration, '0', covariance, '0']
- [ota_calibration, '1', corrected_channels, '1']
- [ota_calibration, '1', corrected_phase_estimator, '1']
- [ota_calibration, '1', covariance, '1']
- [ota_calibration, '2', corrected_channels, '2']
- [ota_calibration, '2', corrected_phase_estimator, '2']
- [ota_calibration, '2', covariance, '2']
- [ota_calibration, '3', corrected_channels, '3']
- [ota_calibration, '3', corrected_phase_estimator, '3']
- [ota_calibration, '3', covariance, '3']
- [peak_finder, '0', peak_magnitude_discard, '0']
- [peak_finder, '1', bearing_validity, '0']
- [bearing_validity, '0', bearing_streams, '0']
- [pilot_filter_0, '0', direct_phase_correction, '0']
- [pilot_filter_0, '0', post_cfo_fft_display, '0']
- [pilot_filter_0, '0', postfilter_phase_estimator, '0']
- [pilot_filter_1, '0', direct_phase_correction, '1']
- [pilot_filter_1, '0', post_cfo_fft_display, '1']
- [pilot_filter_1, '0', postfilter_phase_estimator, '1']
- [pilot_filter_2, '0', direct_phase_correction, '2']
- [pilot_filter_2, '0', post_cfo_fft_display, '2']
- [pilot_filter_2, '0', postfilter_phase_estimator, '2']
- [pilot_filter_3, '0', direct_phase_correction, '3']
- [pilot_filter_3, '0', post_cfo_fft_display, '3']
- [pilot_filter_3, '0', postfilter_phase_estimator, '3']
- [postfilter_phase_estimator, '0', postfilter_phase_display, '0']
- [postfilter_phase_estimator, '1', postfilter_phase_display, '1']
- [postfilter_phase_estimator, '2', postfilter_phase_display, '2']
- [prefilter_phase_estimator, '0', prefilter_phase_display, '0']
- [prefilter_phase_estimator, '1', prefilter_phase_display, '1']
- [prefilter_phase_estimator, '2', prefilter_phase_display, '2']
- [target_filter_0, '0', direct_phase_correction, '4']
- [target_filter_1, '0', direct_phase_correction, '5']
- [target_filter_2, '0', direct_phase_correction, '6']
- [target_filter_3, '0', direct_phase_correction, '7']
- [direct_phase_correction, '0', pilot_aligned_vectorizer, '0']
- [direct_phase_correction, '1', pilot_aligned_vectorizer, '1']
- [direct_phase_correction, '2', pilot_aligned_vectorizer, '2']
- [direct_phase_correction, '3', pilot_aligned_vectorizer, '3']
- [direct_phase_correction, '4', target_aligned_vectorizer, '0']
- [direct_phase_correction, '5', target_aligned_vectorizer, '1']
- [direct_phase_correction, '6', target_aligned_vectorizer, '2']
- [direct_phase_correction, '7', target_aligned_vectorizer, '3']
- [pilot_aligned_vectorizer, '0', pilot_output_decimator, '0']
- [pilot_output_decimator, '0', pilot_aligned_discard, '0']
- [target_aligned_vectorizer, '0', target_output_decimator, '0']
- [target_output_decimator, '0', target_aligned_streams, '0']
- [target_aligned_streams, '0', ota_calibration, '4']
- [target_aligned_streams, '1', ota_calibration, '5']
- [target_aligned_streams, '2', ota_calibration, '6']
- [target_aligned_streams, '3', ota_calibration, '7']
- [target_aligned_streams, '0', ota_calibration, '0']
- [target_aligned_streams, '1', ota_calibration, '1']
- [target_aligned_streams, '2', ota_calibration, '2']
- [target_aligned_streams, '3', ota_calibration, '3']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-1103-g14d6a758
