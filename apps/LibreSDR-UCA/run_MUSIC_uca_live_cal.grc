options:
  parameters:
    author: gr-doa LibreSDR research port
    comment: Four-channel 903 MHz UCA MUSIC with same-session OTA calibration.
    description: Keep this flowgraph running after calibration; switching off the B210 does not invalidate frozen corrections.
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: run_MUSIC_uca_live_cal
    output_language: python
    title: LibreSDR UCA MUSIC - Live OTA Calibration
  states: {}

blocks:
- name: calibration_file
  id: variable
  parameters:
    comment: Diagnostic copy of frozen coefficients
    value: '"/tmp/gr-doa-uca-903MHz.cfg"'
  states: {}
- name: calibration_samples
  id: variable
  parameters:
    comment: Pilot samples used for complex circular averaging
    value: 2**16
  states: {}
- name: calibration_skip
  id: variable
  parameters:
    comment: Allow both network streams and RF chains to settle
    value: 2**14
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: Array and B210 RF center frequency
    value: int(920.9e6)
  states: {}
- name: element0_bearing
  id: variable
  parameters:
    comment: 4.1 RX1 is bottom-right, 225 degrees CCW from the B210 reference
    value: '225.0'
  states: {}
- name: element_bearing_step
  id: variable
  parameters:
    comment: Existing element order proceeds clockwise around the array
    value: '-90.0'
  states: {}
- name: norm_radius
  id: variable
  parameters:
    comment: 114.997 mm radius divided by wavelength at 903 MHz
    value: '0.346379923'
  states: {}
- name: num_elements
  id: variable
  parameters:
    comment: Two RX channels per LibreSDR
    value: '4'
  states: {}
- name: num_targets
  id: variable
  parameters:
    comment: Known number of narrowband incident signals
    value: '1'
  states: {}
- name: overlap_size
  id: variable
  parameters:
    comment: Covariance snapshot overlap
    value: 2**14
  states: {}
- name: pilot_bearing
  id: variable
  parameters:
    comment: Relative reference axis pointing from the array centre to the B210
    value: '90'
  states: {}
- name: proc_rate
  id: variable
  parameters:
    value: samp_rate / 8
  states: {}
- name: pspectrum_len
  id: variable
  parameters:
    comment: 720 bins gives 0.5 degree spacing
    value: '720'
  states: {}
- name: rf_bandwidth
  id: variable
  parameters:
    comment: IIO template value; verify the actual AD9361 attribute (see README)
    value: int(2.8e6)
  states: {}
- name: rx_gain
  id: variable
  parameters:
    comment: Same manual gain on all four channels
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: LibreSDR complex sample rate
    value: int(2.8e6)
  states: {}
- name: snapshot_size
  id: variable
  parameters:
    comment: Samples per MUSIC covariance estimate
    value: 2**15
  states: {}
- name: bearing_display
  id: qtgui_number_sink
  parameters:
    comment: Displays the strongest peak; the MUSIC block supports additional targets.
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 0,0,1,1
    label1: Estimated bearing
    max: '360'
    min: '0'
    name: '"UCA MUSIC bearing"'
    type: float
    unit1: degrees
  states: {}
- name: bearing_streams
  id: blocks_vector_to_streams
  parameters:
    num_streams: num_targets
    type: float
  states: {}
- name: corrected_channels
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: Outputs remain zero until OTA calibration has frozen.
    grid: 'True'
    gui_hint: 0,1,1,1
    label1: Element 0
    label2: Element 1
    label3: Element 2
    label4: Element 3
    label5: ''
    label6: ''
    label7: ''
    label8: ''
    name: '"Calibrated UCA channels"'
    nconnections: '4'
    size: '1024'
    srate: proc_rate
    type: complex
  states: {}
- name: corrected_phase_display
  id: qtgui_time_sink_x
  parameters:
    comment: Continuous corrected pairwise phases from the unchanged Ettus estimator.
    entags: 'False'
    grid: 'True'
    gui_hint: 2,1,1,1
    label1: Corrected ch1/ch0
    label2: Corrected ch2/ch0
    label3: Corrected ch3/ch0
    name: '"Corrected relative phase"'
    nconnections: '3'
    size: '1024'
    srate: proc_rate
    type: float
    ylabel: Phase
    ymax: '3.2'
    ymin: '-3.2'
    yunit: radians
  states: {}
- name: corrected_phase_estimator
  id: doa_phase_offset_est
  parameters:
    comment: Corrected x0*conj(xi) phase. With the pilot present this should match the predicted UCA geometry and remain stable.
    n_skip_ahead: calibration_skip + calibration_samples
    num_inputs: num_elements
  states: {}
- name: covariance
  id: doa_autocorrelate
  parameters:
    avg_method: Forward
    comment: 'Forward-only covariance: ULA reversal averaging is not used for the UCA.'
    inputs: num_elements
    overlap_size: overlap_size
    snapshot_size: snapshot_size
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 5e3
    decim: '8'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, 10e3, 15e3)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 5e3
    decim: '8'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, 10e3, 15e3)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 5e3
    decim: '8'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, 10e3, 15e3)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 5e3
    decim: '8'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, 10e3, 15e3)
    type: ccc
  states: {}
- name: libresdr_a
  id: iio_fmcomms2_source
  parameters:
    bandwidth: rf_bandwidth
    bbdc: 'True'
    buffer_size: '32768'
    comment: 'Existing wiring: RX1 bottom-right is element 0; RX2 bottom-left is element 1.'
    filter_source: '''Auto'''
    frequency: center_freq
    gain1: '''manual'''
    gain2: '''manual'''
    manual_gain1: rx_gain
    manual_gain2: rx_gain
    quadrature: 'True'
    rf_port_select: '''A_BALANCED'''
    rfdc: 'True'
    rx1_en: 'True'
    rx2_en: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.4.1
  states: {}
- name: libresdr_b
  id: iio_fmcomms2_source
  parameters:
    bandwidth: rf_bandwidth
    bbdc: 'True'
    buffer_size: '32768'
    comment: 'Existing wiring is permuted below: RX2 top-left is element 2; RX1 top-right is element 3.'
    filter_source: '''Auto'''
    frequency: center_freq
    gain1: '''manual'''
    gain2: '''manual'''
    manual_gain1: rx_gain
    manual_gain2: rx_gain
    quadrature: 'True'
    rf_port_select: '''A_BALANCED'''
    rfdc: 'True'
    rx1_en: 'True'
    rx2_en: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.5.1
  states: {}
- name: music_uca
  id: doa_MUSIC_uca
  parameters:
    comment: Full-circle UCA steering model.
    element0_angle: element0_bearing
    element_angle_step: element_bearing_step
    inputs: num_elements
    norm_radius: norm_radius
    num_targets: num_targets
    pspectrum_len: pspectrum_len
  states: {}
- name: ota_calibration
  id: doa_uca_pilot_calibration
  parameters:
    calibration_samples: calibration_samples
    comment: Pilot must be on before start. Wait for the console completion message.
    config_filename: calibration_file
    element0_angle: element0_bearing
    element_angle_step: element_bearing_step
    norm_radius: norm_radius
    num_inputs: num_elements
    pilot_angle: pilot_bearing
    skip_samples: calibration_skip
  states: {}
- name: peak_finder
  id: doa_find_local_max
  parameters:
    num_max_vals: num_targets
    vector_len: pspectrum_len
    x_max: '360.0'
    x_min: '0.0'
  states: {}
- name: peak_magnitude_discard
  id: blocks_null_sink
  parameters:
    type: float
    vlen: num_targets
  states: {}
- name: qtgui_compass_0
  id: qtgui_compass
  parameters:
    fullNeedle: '1'
    min_size: '250'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: raw_phase_display
  id: qtgui_time_sink_x
  parameters:
    comment: Continuous raw pairwise phases from the unchanged Ettus estimator.
    entags: 'False'
    grid: 'True'
    gui_hint: 2,0,1,1
    label1: Raw ch1/ch0
    label2: Raw ch2/ch0
    label3: Raw ch3/ch0
    name: '"Raw relative phase"'
    nconnections: '3'
    size: '1024'
    srate: proc_rate
    type: float
    ylabel: Phase
    ymax: '3.2'
    ymin: '-3.2'
    yunit: radians
  states: {}
- name: raw_phase_estimator
  id: doa_phase_offset_est
  parameters:
    comment: Uncorrected x0*conj(xi) phase. Stable traces are required for coherent MUSIC.
    n_skip_ahead: calibration_skip
    num_inputs: num_elements
  states: {}
- name: spectrum_display
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    gui_hint: 1,0,1,2
    label1: MUSIC pseudo-spectrum
    name: '"Full-circle UCA MUSIC"'
    showports: 'True'
    vlen: pspectrum_len
    width1: '2'
    x_axis_label: '"Bearing (degrees)"'
    x_start: '0'
    x_step: 360.0/pspectrum_len
    x_units: '"degrees"'
    y_axis_label: '"Normalized pseudo-spectrum (dB)"'
    y_units: '"dB"'
    ymax: '0'
    ymin: '-40'
  states: {}

connections:
- [bearing_streams, '0', bearing_display, '0']
- [bearing_streams, '0', qtgui_compass_0, '0']
- [corrected_phase_estimator, '0', corrected_phase_display, '0']
- [corrected_phase_estimator, '1', corrected_phase_display, '1']
- [corrected_phase_estimator, '2', corrected_phase_display, '2']
- [covariance, '0', music_uca, '0']
- [freq_xlating_fir_filter_xxx_0, '0', ota_calibration, '0']
- [freq_xlating_fir_filter_xxx_0, '0', raw_phase_estimator, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', ota_calibration, '1']
- [freq_xlating_fir_filter_xxx_0_0, '0', raw_phase_estimator, '1']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', ota_calibration, '3']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', raw_phase_estimator, '3']
- [freq_xlating_fir_filter_xxx_0_0_1, '0', ota_calibration, '2']
- [freq_xlating_fir_filter_xxx_0_0_1, '0', raw_phase_estimator, '2']
- [libresdr_a, '0', freq_xlating_fir_filter_xxx_0, '0']
- [libresdr_a, '0', qtgui_freq_sink_x_0, '0']
- [libresdr_a, '1', freq_xlating_fir_filter_xxx_0_0, '0']
- [libresdr_b, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [libresdr_b, '1', freq_xlating_fir_filter_xxx_0_0_1, '0']
- [music_uca, '0', peak_finder, '0']
- [music_uca, '0', spectrum_display, '0']
- [ota_calibration, '0', corrected_channels, '0']
- [ota_calibration, '0', corrected_phase_estimator, '0']
- [ota_calibration, '0', covariance, '0']
- [ota_calibration, '1', corrected_channels, '1']
- [ota_calibration, '1', corrected_phase_estimator, '1']
- [ota_calibration, '1', covariance, '1']
- [ota_calibration, '2', corrected_channels, '2']
- [ota_calibration, '2', corrected_phase_estimator, '2']
- [ota_calibration, '2', covariance, '2']
- [ota_calibration, '3', corrected_channels, '3']
- [ota_calibration, '3', corrected_phase_estimator, '3']
- [ota_calibration, '3', covariance, '3']
- [peak_finder, '0', peak_magnitude_discard, '0']
- [peak_finder, '1', bearing_streams, '0']
- [raw_phase_estimator, '0', raw_phase_display, '0']
- [raw_phase_estimator, '1', raw_phase_display, '1']
- [raw_phase_estimator, '2', raw_phase_display, '2']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-1103-g14d6a758
