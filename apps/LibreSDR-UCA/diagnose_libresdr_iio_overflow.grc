options:
  parameters:
    author: gr-doa LibreSDR research port
    comment: Minimal four-channel LibreSDR receive-path overflow diagnostic.
    description: Streams both RX channels from both LibreSDRs directly into a null sink for a fixed interval. Any printed O is an IIO receive overflow independent of CFO correction, calibration, MUSIC, and GUI processing.
    generate_options: no_gui
    generator_class_name: PythonNoGuiGenerator
    generator_module: gnuradio.grc.workflows.python_nogui
    id: diagnose_libresdr_iio_overflow
    output_language: python
    run_options: run
    title: LibreSDR Four-Channel IIO Overflow Diagnostic
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    comment: Match the live UCA receiver centre frequency
    value: int(700e6)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Same reduced sample rate used for the live diagnostic run
    value: int(525e3)
  states: {}
- name: rf_bandwidth
  id: variable
  parameters:
    comment: Requested AD9361 RF bandwidth
    value: int(2.8e6)
  states: {}
- name: rx_gain
  id: variable
  parameters:
    comment: Same manual gain on all four channels
    value: '40'
  states: {}
- name: test_seconds
  id: variable
  parameters:
    comment: Diagnostic duration; every channel must deliver this many samples
    value: '20'
  states: {}
- name: pps_sync_after_start
  id: snippet
  parameters:
    code: doa.arm_libresdr_pps_sync(('ip:192.168.4.1', 'ip:192.168.5.1'))
    section: main_after_start
  states: {}
- name: libresdr_a
  id: iio_fmcomms2_source
  parameters:
    bandwidth: rf_bandwidth
    bbdc: 'True'
    buffer_size: '262144'
    comment: Alpha; RX1 is ch0 and RX2 is ch1.
    filter_source: '''Auto'''
    frequency: center_freq
    gain1: '''manual'''
    gain2: '''manual'''
    manual_gain1: rx_gain
    manual_gain2: rx_gain
    quadrature: 'False'
    rf_port_select: '''A_BALANCED'''
    rfdc: 'True'
    rx1_en: 'True'
    rx2_en: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.4.1
  states: {}
- name: libresdr_b
  id: iio_fmcomms2_source
  parameters:
    bandwidth: rf_bandwidth
    bbdc: 'True'
    buffer_size: '262144'
    comment: Bravo; RX1 and RX2 are both consumed without permutation because this test only checks transport.
    filter_source: '''Auto'''
    frequency: center_freq
    gain1: '''manual'''
    gain2: '''manual'''
    manual_gain1: rx_gain
    manual_gain2: rx_gain
    quadrature: 'False'
    rf_port_select: '''A_BALANCED'''
    rfdc: 'True'
    rx1_en: 'True'
    rx2_en: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.5.1
  states: {}
- name: alpha_rx1_head
  id: blocks_head
  parameters:
    comment: Stops Alpha RX1 after the fixed test interval
    num_items: int(test_seconds * samp_rate)
    type: complex
  states: {}
- name: alpha_rx2_head
  id: blocks_head
  parameters:
    comment: Stops Alpha RX2 after the fixed test interval
    num_items: int(test_seconds * samp_rate)
    type: complex
  states: {}
- name: bravo_rx1_head
  id: blocks_head
  parameters:
    comment: Stops Bravo RX1 after the fixed test interval
    num_items: int(test_seconds * samp_rate)
    type: complex
  states: {}
- name: bravo_rx2_head
  id: blocks_head
  parameters:
    comment: Stops Bravo RX2 after the fixed test interval
    num_items: int(test_seconds * samp_rate)
    type: complex
  states: {}
- name: all_channels_sink
  id: blocks_null_sink
  parameters:
    comment: Consumes all four streams without DSP or GUI work
    num_inputs: '3'
    type: complex
  states: {}
- name: alpha_rx1_rate
  id: blocks_probe_rate
  parameters:
    alpha: '0.25'
    mintime: '2000.0'
    name: '"Alpha RX1 source-only rate"'
    type: complex
  states: {}
- name: rate_messages
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {}

connections:
- [alpha_rx1_head, '0', alpha_rx1_rate, '0']
- [alpha_rx1_rate, rate, rate_messages, print]
- [alpha_rx2_head, '0', all_channels_sink, '0']
- [bravo_rx1_head, '0', all_channels_sink, '1']
- [bravo_rx2_head, '0', all_channels_sink, '2']
- [libresdr_a, '0', alpha_rx1_head, '0']
- [libresdr_a, '1', alpha_rx2_head, '0']
- [libresdr_b, '0', bravo_rx1_head, '0']
- [libresdr_b, '1', bravo_rx2_head, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-1103-g14d6a758
