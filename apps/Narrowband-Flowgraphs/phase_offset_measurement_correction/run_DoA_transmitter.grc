options:
  parameters:
    author: Ettus Research; LibreSDR UCA configuration
    comment: Dual-channel B210 source for LibreSDR UCA calibration and direction finding.
    description: TX/RX0 sends the fixed +140 kHz calibration pilot; TX/RX1 sends the movable +150 kHz direction-finding target. The fixed beacon is transmitted 15 dB below the target to prevent stop-band leakage into the target selector.
    generate_options: no_gui
    generator_class_name: PythonNoGuiGenerator
    generator_module: gnuradio.grc.workflows.python_nogui
    hier_block_src_path: ''
    id: run_DoA_transmitter
    output_language: python
    title: B210 Dual-Channel Calibration and Target TX
  states: {}

blocks:
- name: input_variables
  id: variable_struct
  parameters:
    comment: TX/RX0 is the stationary calibration antenna; TX/RX1 is the movable target antenna. Offsets must match the receiver pilot_offset and target_offset.
    field0: PilotToneFreq
    field1: SampleRate
    field2: CenterFreq
    field3: TxAddr
    field4: Gain
    field5: TargetToneFreq
    value0: 140e3
    value1: 1e6
    value2: 700e6
    value3: '"serial=310C4AE"'
    value4: '40'
    value5: 150e3
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Fixed calibration beacon connected to B210 TX/RX0
    freq: input_variables.PilotToneFreq
    offset: '0'
    phase: '0'
    samp_rate: input_variables.SampleRate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Movable direction-finding target connected to B210 TX/RX1
    freq: input_variables.TargetToneFreq
    offset: '0'
    phase: '0'
    samp_rate: input_variables.SampleRate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: pilot_am_marker
  id: analog_sig_source_x
  parameters:
    amp: '0.25'
    comment: First component of the amplitude signature used by the receiver to measure inter-board stream item lag before phase calibration.
    freq: '997'
    offset: '1.0'
    phase: '0'
    samp_rate: input_variables.SampleRate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: pilot_am_marker_2
  id: analog_sig_source_x
  parameters:
    amp: '0.20'
    comment: Incommensurate second component makes the lag-correlation peak unique.
    freq: '1613'
    offset: '0.0'
    phase: '0.37'
    samp_rate: input_variables.SampleRate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: pilot_marker_add
  id: blocks_add_xx
  parameters:
    type: float
  states: {state: disabled}
- name: pilot_marker_complex
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: pilot_marker_multiply
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: pilot_pn_source
  id: digital_glfsr_source_x
  parameters:
    degree: '7'
    mask: '0'
    repeat: 'True'
    seed: '1'
    type: float
  states: {}
- name: pilot_pn_repeat
  id: blocks_repeat
  parameters:
    interp: '1000'
    type: float
  states: {}
- name: pilot_pn_scale
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.4'
    mode: scalar
    type: float
  states: {}
- name: pilot_pn_offset
  id: blocks_add_const_vxx
  parameters:
    const: '1.0'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Calibration pilot baseband"'
    size: '1024'
    srate: input_variables.SampleRate
    type: complex
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: input_variables.CenterFreq
    center_freq1: input_variables.CenterFreq
    clock_rate: '0.0'
    clock_source0: internal
    dev_addr: input_variables.TxAddr
    dev_args: '""'
    gain0: input_variables.Gain - 15
    gain1: input_variables.Gain
    len_tag_name: ''
    nchan: '2'
    samp_rate: input_variables.SampleRate
    stream_chans: '[0, 1]'
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', pilot_marker_multiply, '0']
- [analog_sig_source_x_1, '0', uhd_usrp_sink_0, '1']
- [pilot_am_marker, '0', pilot_marker_add, '0']
- [pilot_am_marker_2, '0', pilot_marker_add, '1']
- [pilot_pn_source, '0', pilot_pn_repeat, '0']
- [pilot_pn_repeat, '0', pilot_pn_scale, '0']
- [pilot_pn_scale, '0', pilot_pn_offset, '0']
- [pilot_pn_offset, '0', pilot_marker_complex, '0']
- [pilot_marker_complex, '0', pilot_marker_multiply, '1']
- [pilot_marker_multiply, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-1103-g14d6a758
