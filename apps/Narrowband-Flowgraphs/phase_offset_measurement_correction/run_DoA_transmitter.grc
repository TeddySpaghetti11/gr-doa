options:
  parameters:
    author: Ettus Research; LibreSDR UCA configuration
    comment: Dual-channel B210 source for LibreSDR UCA calibration and direction finding.
    description: TX/RX0 sends the fixed +50 kHz calibration pilot; TX/RX1 sends the movable +150 kHz direction-finding target. Both use 40 dB gain.
    generate_options: no_gui
    generator_class_name: PythonNoGuiGenerator
    generator_module: gnuradio.grc.workflows.python_nogui
    hier_block_src_path: ''
    id: run_DoA_transmitter
    output_language: python
    title: B210 Dual-Channel Calibration and Target TX
  states: {}

blocks:
- name: input_variables
  id: variable_struct
  parameters:
    comment: TX/RX0 is the stationary calibration antenna; TX/RX1 is the movable target antenna. Offsets must match the receiver pilot_offset and target_offset.
    field0: PilotToneFreq
    field1: SampleRate
    field2: CenterFreq
    field3: TxAddr
    field4: Gain
    field5: TargetToneFreq
    value0: 50e3
    value1: 1e6
    value2: 700e6
    value3: '"serial=310C4AE"'
    value4: '40'
    value5: 150e3
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Fixed calibration beacon connected to B210 TX/RX0
    freq: input_variables.PilotToneFreq
    offset: '0'
    phase: '0'
    samp_rate: input_variables.SampleRate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Movable direction-finding target connected to B210 TX/RX1
    freq: input_variables.TargetToneFreq
    offset: '0'
    phase: '0'
    samp_rate: input_variables.SampleRate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Calibration pilot baseband"'
    size: '1024'
    srate: input_variables.SampleRate
    type: complex
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: input_variables.CenterFreq
    center_freq1: input_variables.CenterFreq
    clock_rate: '0.0'
    clock_source0: internal
    dev_addr: input_variables.TxAddr
    dev_args: '""'
    gain0: input_variables.Gain
    gain1: input_variables.Gain
    len_tag_name: ''
    nchan: '2'
    samp_rate: input_variables.SampleRate
    stream_chans: '[0, 1]'
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_1, '0', uhd_usrp_sink_0, '1']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-1103-g14d6a758
