options:
  parameters:
    author: jreitmei
    generate_options: no_gui
    generator_class_name: PythonNoGuiGenerator
    generator_module: gnuradio.grc.workflows.python_nogui
    id: calibrate_lin_array
    output_language: python
    title: calibrate linear array
  states: {}

blocks:
- name: antenna_calibration_file_name
  id: variable
  parameters:
    value: os.path.join(input_variables.DirectoryConfigFiles, input_variables.AntennaCalibration)
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: '2800000'
  states: {}
- name: freq
  id: variable
  parameters:
    value: int(1.24086e9)
  states: {}
- name: input_variables
  id: variable_struct
  parameters:
    field0: ''
    field1: SampleRate
    field10: DirectoryConfigFiles
    field11: RelativePhaseOffsets
    field12: AntennaCalibration
    field13: Samples2Avg
    field2: CenterFreq
    field3: RxAddr
    field5: NumArrayElements
    field6: NormSpacing
    field7: SnapshotSize
    field8: OverlapSize
    field9: PilotAngle
    value1: 1e6
    value10: '"/tmp"'
    value11: '"measure_relative_phase_offsets_2495MHz.cfg"'
    value12: '"calibration_lin_array_2495MHz.cfg"'
    value13: 2**11
    value2: 2.495e9
    value3: '"addr=10.94.17.65"'
    value5: '2'
    value6: '0.1208'
    value7: 2**11
    value8: 2**10
    value9: '90'
  states: {}
- name: rel_phase_offsets_file_name
  id: variable
  parameters:
    value: os.path.join(input_variables.DirectoryConfigFiles, input_variables.RelativePhaseOffsets)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(2.8e6)
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters:
    vlen: input_variables.NumArrayElements
  states: {state: disabled}
- name: blocks_complex_to_magphase_0_0
  id: blocks_complex_to_magphase
  parameters:
    vlen: input_variables.NumArrayElements
  states: {}
- name: doa_autocorrelate_0
  id: doa_autocorrelate
  parameters:
    avg_method: Forward-Backward
    inputs: input_variables.NumArrayElements
    overlap_size: input_variables.OverlapSize
    snapshot_size: input_variables.SnapshotSize
  states: {state: disabled}
- name: doa_autocorrelate_0_0
  id: doa_autocorrelate
  parameters:
    avg_method: Forward-Backward
    inputs: input_variables.NumArrayElements
    overlap_size: input_variables.OverlapSize
    snapshot_size: input_variables.SnapshotSize
  states: {}
- name: doa_calibrate_lin_array_0
  id: doa_calibrate_lin_array
  parameters:
    norm_spacing: input_variables.NormSpacing
    num_ant_ele: input_variables.NumArrayElements
    pilot_angle: input_variables.PilotAngle
  states: {state: disabled}
- name: doa_calibrate_lin_array_0_0
  id: doa_calibrate_lin_array
  parameters:
    norm_spacing: input_variables.NormSpacing
    num_ant_ele: input_variables.NumArrayElements
    pilot_angle: input_variables.PilotAngle
  states: {}
- name: doa_phase_correct_hier_0
  id: doa_phase_correct_hier
  parameters:
    config_filename: rel_phase_offsets_file_name
    num_ports: input_variables.NumArrayElements
  states: {state: disabled}
- name: doa_phase_correct_hier_0_0
  id: doa_phase_correct_hier
  parameters:
    config_filename: rel_phase_offsets_file_name
    num_ports: input_variables.NumArrayElements
  states: {}
- name: doa_save_antenna_calib_0
  id: doa_save_antenna_calib
  parameters:
    config_filename: antenna_calibration_file_name
    num_inputs: input_variables.NumArrayElements
    samples_to_average: input_variables.Samples2Avg
  states: {state: disabled}
- name: doa_save_antenna_calib_0_0
  id: doa_save_antenna_calib
  parameters:
    config_filename: antenna_calibration_file_name
    num_inputs: input_variables.NumArrayElements
    samples_to_average: input_variables.Samples2Avg
  states: {}
- name: doa_x440_usrp_source_0
  id: doa_x440_usrp_source
  parameters:
    addresses: input_variables.RxAddr
    center_freq: input_variables.CenterFreq
    device_args: master_clock_rate=250e6
    samp_rate: input_variables.SampleRate
    sources: input_variables.NumArrayElements
  states: {state: disabled}
- name: iio_fmcomms2_source_0
  id: iio_fmcomms2_source
  parameters:
    bandwidth: bandwidth
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: freq
    gain1: '''slow_attack'''
    gain2: '''slow_attack'''
    quadrature: 'True'
    rf_port_select: '''A_BALANCED'''
    rfdc: 'True'
    rx1_en: 'True'
    rx2_en: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.1.10
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import os
  states: {}

connections:
- [blocks_complex_to_magphase_0, '0', doa_save_antenna_calib_0, '0']
- [blocks_complex_to_magphase_0, '1', doa_save_antenna_calib_0, '1']
- [blocks_complex_to_magphase_0_0, '0', doa_save_antenna_calib_0_0, '0']
- [blocks_complex_to_magphase_0_0, '1', doa_save_antenna_calib_0_0, '1']
- [doa_autocorrelate_0, '0', doa_calibrate_lin_array_0, '0']
- [doa_autocorrelate_0_0, '0', doa_calibrate_lin_array_0_0, '0']
- [doa_calibrate_lin_array_0, '0', blocks_complex_to_magphase_0, '0']
- [doa_calibrate_lin_array_0_0, '0', blocks_complex_to_magphase_0_0, '0']
- [doa_phase_correct_hier_0, '0', doa_autocorrelate_0, '0']
- [doa_phase_correct_hier_0, '1', doa_autocorrelate_0, '1']
- [doa_phase_correct_hier_0_0, '0', doa_autocorrelate_0_0, '0']
- [doa_phase_correct_hier_0_0, '1', doa_autocorrelate_0_0, '1']
- [doa_x440_usrp_source_0, '0', doa_phase_correct_hier_0, '0']
- [doa_x440_usrp_source_0, '1', doa_phase_correct_hier_0, '1']
- [iio_fmcomms2_source_0, '0', doa_phase_correct_hier_0_0, '0']
- [iio_fmcomms2_source_0, '1', doa_phase_correct_hier_0_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
